# Keil uVision project bootcode.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: bootcode +hex
  AfterMake: .\Tools\ConvIntelHex_V2.7.exe .\out\bootcode.hex -ed [0,1000]
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __NO_EMBEDDED_ASM
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A31G21x\Include;..\..\..\..\Drivers\include;..\..\bootcode
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Startup
    ../../../../Core/Device/ABOV/A31G21x/Source/ARM/: startup_A31G21x_bootkeil.s
  group CMSIS-CM0P
    ../../../../Core/Device/ABOV/A31G21x/Source/: system_A31G21x.c
  group Drivers
    ../../../../Drivers/source/: A31G21x_scu.c A31G21x_pcu.c A31G21x_uartn.c A31G21x_usart1n.c
  group Main
    ../: main.c flash.c
