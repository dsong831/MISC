# Keil uVision project bootcodeFG316.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: bootcodeFG316 +hex
  AfterMake: $H\..\hex2byte.exe "#H" "$Hbootcode.c"
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Sources/: startup.a51 main.c uart.c flash.c asm.a51
