# Keil uVision project Gpio_LedBlinky.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Gpio_LedBlinky100 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: KEIL_PRJ
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A31G21x\Include;..\..\..\..\Drivers\include;..\Keil
  memory RVCT4: ROM 0x1000 size 0xf000
  memory RVCT5: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Startup
    ../../../../Core/Device/ABOV/A31G21x/Source/ARM/: startup_A31G21x.s
  group CMSIS-CM0P
    ../../../../Core/Device/ABOV/A31G21x/Source/: system_A31G21x.c
  group Drivers
    ../../../../Drivers/source/: A31G21x_scu.c A31G21x_pcu.c
  group Main
    ../: main.c bootcode.C
software components: CMSIS:CORE 4.3.0
